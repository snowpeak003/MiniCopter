# Keil uVision project coaxcopter.uvproj, settings and files
target coaxcopter (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: coaxcopter +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\MY_LIB;..\STM32_LIB\CMSIS\Include;..\STM32_LIB\CMSIS\Device\ST\STM32F4xx\Include;..\USER;..\STM32_LIB\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../STM32_LIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../STM32_LIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_i2c.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group CMIS
    ../STM32_LIB/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group README
    ../README/: README.txt
  group MY_LIB
    ../MY_LIB/: LED.c Tim_Pwm_Out.c I2c_Soft.c MPU6050.c Usart.c Usart2.c Usart3.c Tim_Pwm_In.c Rc.c Timer.c IMU.c Control.c Filter.c Protocol.c Mymath.c spi_nanopi.c Tim_PPM_In.c Control_Nanopi.c Usart6.c
  group USER
    ../USER/: main.c stm32f4xx_it.c Tasks.c
